# Keil uVision project cathack.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: cathack +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER STM32F0XX
  c include: ..\Libraries\CMSIS\Include;..\Libraries\CMSIS\ST\STM32F0xx\Include;..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\Libraries\STMTouch_Driver\inc;.\src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./: startup_stm32f0xx.s
  group src
    ./src/: main.c pd_pwm.c utils.c pd_gpio.c
  group include
    ../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_tim.c stm32f0xx_misc.c stm32f0xx_adc.c
    ../Libraries/CMSIS/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
    ../Libraries/CMSIS/ST/STM32F0xx/Include/: stm32f0xx.h
